FILESEXTRAPATHS_prepend := "${THISDIR}/ntp:"
