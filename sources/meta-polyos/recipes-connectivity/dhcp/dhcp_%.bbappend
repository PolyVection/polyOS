FILESEXTRAPATHS_prepend := "${THISDIR}/dhcp:"
