DEPENDS_append += " libtool"
